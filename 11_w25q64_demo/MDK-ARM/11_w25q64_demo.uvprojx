# Keil uVision project 11_w25q64_demo.uvprojx, settings and files
target 11_w25q64_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 10_spi_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../2_Devices;../3_ModuleDrvs;../4_Includes;../5_Lib/printf;../5_Lib/ring_buffer;../3_ModuleDrvs/dev_config;../5_Lib;../2_Devices/w25q
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group 1_Applications
    ../1_Applications/: app_w25q64_test.c
  group 2_Devices
    ../2_Devices/: dev_gpio.c dev_uart.c dev_spi.h dev_spi.c devices.h
    ../2_Devices/w25q/: w25q64.c w25qxx.h
  group 3_ModuleDrvs
    ../3_ModuleDrvs/: drv_gpio.c drv_uart.c drv_spi.h drv_spi.c drivers.h
  group 4_Includes
    ../4_Includes/: config.h errno.h my_type.h
  group 5_Libs
    ../5_Lib/printf/: printf.c
    ../5_Lib/ring_buffer/: ring_buffer.c
    ../5_Lib/: libs.h
software components: CMSIS:CORE 4.3.0
