# Keil uVision project 12_display_st7789_demo.uvprojx, settings and files
target 12_display_st7789_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 12_display_st7789_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../2_Devices;../2_Devices/display;../3_ModuleDrvs;../3_ModuleDrvs/dev_config;../4_Includes;../5_Lib;../5_Lib/printf;../5_Lib/ring_buffer;../5_Lib/delay
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group 1_Applications
    ../1_Applications/: app_st7789v_test.c
  group 2_Devices
    ../2_Devices/: dev_gpio.c dev_spi.c dev_uart.c devices.h
    ../2_Devices/display/: dev_display.h dev_st7789v.c dev_st7789v.h
  group 3_ModuleDrivers
    ../3_ModuleDrvs/: drv_gpio.c drv_spi.c drv_uart.c
    ../3_ModuleDrvs/dev_config/: gpio_config.h spi_config.h uart_config.h
  group 4_Includes
    ../4_Includes/: config.h errno.h my_type.h
  group 5_Libs
    ../5_Lib/ring_buffer/: ring_buffer.c
    ../5_Lib/printf/: printf.c
    ../5_Lib/: libs.h
    ../5_Lib/delay/: my_delay.h my_delay.c
software components: CMSIS:CORE 4.3.0
